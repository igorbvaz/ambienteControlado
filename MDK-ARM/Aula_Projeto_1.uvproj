# Keil uVision project Aula_Projeto_1.uvproj, settings and files
target Project_1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project_1
  c flags: Optim=4 OneElfS=1
  c define: HSE_VALUE=8000000 USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: system_stm32f4xx.c main.c
    ./: LED.c
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group MDK-ARM
    ../: startup_stm32f40xx.s
